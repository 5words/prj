# Keil uVision project test.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC1114FBD48/302 NXP
  pack: Keil.LPC1100_DFP.1.4.0
  cpu: IRAM(0x10000000,0x2000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: test
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group Source Group 1
    ./: main.c LM75A.c
software components: CMSIS:CORE 5.1.2, CMSIS:RTOS:Keil RTX5 5.4.0, CMSIS:RTOS2:Keil RTX5 5.4.0, CMSIS Driver:I2C:Multi-Slave 1.0.1, CMSIS Driver:SPI:Multi-Slave 1.0.1, Device:Startup 1.0.0
